# OrCAD Capture schematic CC26x1-P3EM-5XS24-PA24_10dBm.DSN, sheet 2 of 3 (continued)
## Nets (continued)
JTAG_TMS: P2.4 U1.18(JTAG_TMSC)
nRESET: C351.1 P2.15 R351.1 U1.27(nRESET)
RX_TX: U1.7(RX_TX)
N485705: C81.1 U1.8(X32K_Q1) Y1.1
N501936: C471.1 U1.39(X24M_P) Y2.1
N501950: C461.1 U1.38(X24M_N) Y2.3
N510840: C482.2 L21.2 L332.1 U1.1(2_4GHZ_RF_P)
N517777: C61.2 L51.1 L61.1 U1.6(TX_20DBM_N)
N517785: C53.1 L51.2 L52.2 U1.5(TX_20DBM_P)
N517815: C53.2 C54.1 L53.1 L61.2
N517942: C55.1 L53.2 L54.1
N518069: C56.1 C57.1 L54.2
N619141: C231.1 U1.17(DCOUPL)
N621290: C91.1 U1.9(X32K_Q2) Y1.2
N2446837: C57.2 J1.1
N2472023: L21.1 U1.2(2_4GHZ_RF_N)
N2472085: C483.2 C484.1 L332.2
N2472556: C484.2 J2.1

Not connected (* = marked no-connect by the designer): P1 5* 8* 10* 11*; P2 3* 5* 6* 10* 11* 12* 13* 14* 16*; U1 3(NC)* 4(NC)*

## Notes on the sheets
sheet 2
- VDDS Decoupling
- VDDR Decoupling
- Pin 26
- Pin 13
- Pin 15
- Pin 36
- Pin 37
- Pin 40
- 5dBm 2.4GHz output
- 10dBm 2.4GHz output
- EM connector 1
- EM connector 2
